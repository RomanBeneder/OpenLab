# Keil uVision project blink_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 IP Core Oregano Systems
  cpu: IRAM(0-0x7F) XRAM(0-0xFFFF) IROM(0-0xFFF) CLOCK(12000000)
  output: blink_led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c
