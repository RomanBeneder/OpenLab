* /home/cmatar/Technikum/Bachelorarbeit/circuit/circuit.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Mit 16 Nov 2016 20:17:52 CET

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
CH1  DIVIDER_0 GND BNC
CH2  DIVIDER_1 GND BNC
SW1  GND RESET_RTC RESET
R15  +3.3V RESET_RTC 10k
C6  RESET_RTC GND 100n
R2  PWM_1 Net-_C2-Pad1_ 33k
C2  Net-_C2-Pad1_ GND 470n
C4  +5V GND 100n
R1  PWM_0 Net-_C1-Pad1_ 33k
C1  Net-_C1-Pad1_ GND 470n
C3  +5V GND 100n
USB1  Net-_R16-Pad1_ Net-_R22-Pad2_ Net-_R19-Pad2_ Net-_C11-Pad2_ GND USB
R20  DIVIDER_0 Net-_D5-Pad1_ 4k7
D5  Net-_D5-Pad1_ GND LED
D7  GND Net-_D5-Pad1_ LED
R21  DIVIDER_1 Net-_D6-Pad1_ 4k7
R26  GND Net-_D6-Pad1_ 100
D6  Net-_D6-Pad1_ GND LED
D8  GND Net-_D6-Pad1_ LED
R25  GND Net-_D5-Pad1_ 100
PCF2127AT1  Net-_LPC1343FBD1-Pad15_ GND GND Net-_LPC1343FBD1-Pad16_ Net-_C13-Pad2_ ? Net-_PCF2127AT1-Pad7_ GND ? ? ? ? ? Net-_PCF2127AT1-Pad14_ Net-_PCF2127AT1-Pad15_ RESET_RTC RTC_INT_11 Net-_C13-Pad2_ GND Net-_C14-Pad2_ PFC2127AT
SWD1  +3.3V +3.3V ? GND ? GND Net-_LPC1343FBD1-Pad39_ GND SWC_29 GND Net-_R9-Pad1_ GND MOSI0_28 GND ? GND Net-_R8-Pad1_ GND +5V_JLINK GND BH20S
R7  +3.3V Net-_LPC1343FBD1-Pad39_ 10k
R8  Net-_R8-Pad1_ GND 10k
R9  Net-_R9-Pad1_ GND 10k
R10  SWC_29 GND 10k
R22  Net-_C8-Pad2_ Net-_R22-Pad2_ 33k
R23  Net-_R19-Pad2_ Net-_C9-Pad2_ 33k
C8  GND Net-_C8-Pad2_ 100n
C9  GND Net-_C9-Pad2_ 100n
R19  Net-_D2-Pad2_ Net-_R19-Pad2_ 1.5k
R17  GND Net-_D2-Pad1_ 560
jfet1  Net-_LPC1343FBD1-Pad22_ +3.3V Net-_D2-Pad2_ DTA114Y
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ LED
C11  GND Net-_C11-Pad2_ 10n
R16  Net-_R16-Pad1_ Net-_LPC1343FBD1-Pad14_ 1k
R18  Net-_R16-Pad1_ +3.3V 10k
R29  Net-_D9-Pad1_ GND 560
D9  Net-_D9-Pad1_ +3.3V POWER
C12  +3.3V GND 100n
R27  +3.3V Net-_LM1-Pad3_ 240
R24  Net-_LM1-Pad3_ GND 390
LM1  Net-_C10-Pad1_ +3.3V Net-_LM1-Pad3_ LM1117
D3  Net-_C10-Pad1_ +3.3V LED
D4  Net-_C10-Pad1_ +5V_JLINK LED
C7  Net-_C7-Pad1_ GND 100n
R28  Net-_PCF2127AT1-Pad7_ +3.3V 10k
C14  GND Net-_C14-Pad2_ 100n
C15  GND Net-_C14-Pad2_ 6.8n
R30  Net-_C14-Pad2_ +3.3V 330
C13  GND Net-_C13-Pad2_ 100n
R31  RTC_INT_11 +3.3V 10k
R32  RESET_RTC +3.3V 10k
C5  GND +3.3V 100n
LPC1343FBD1  Net-_LPC1343FBD1-Pad1_ Net-_LPC1343FBD1-Pad2_ RESET_RTC Net-_LPC1343FBD1-Pad4_ GND Net-_LPC1343FBD1-Pad6_ Net-_LPC1343FBD1-Pad7_ Net-_C7-Pad1_ Net-_LPC1343FBD1-Pad9_ Net-_LPC1343FBD1-Pad10_ RTC_INT_11 Net-_LPC1343FBD1-Pad12_ ? Net-_LPC1343FBD1-Pad14_ Net-_LPC1343FBD1-Pad15_ Net-_LPC1343FBD1-Pad16_ PWM_0 ? Net-_C8-Pad2_ Net-_C9-Pad2_ ? Net-_LPC1343FBD1-Pad22_ ? ? Net-_LPC1343FBD1-Pad25_ Net-_LPC1343FBD1-Pad26_ Net-_LPC1343FBD1-Pad27_ MOSI0_28 SWC_29 PWM_1 Net-_LPC1343FBD1-Pad31_ Net-_LPC1343FBD1-Pad32_ TRIGGER_1 Net-_LPC1343FBD1-Pad34_ Net-_LPC1343FBD1-Pad35_ Net-_LPC1343FBD1-Pad36_ Net-_LPC1343FBD1-Pad37_ Net-_LPC1343FBD1-Pad38_ Net-_LPC1343FBD1-Pad39_ Net-_LPC1343FBD1-Pad40_ GND Net-_LPC1343FBD1-Pad42_ Net-_LPC1343FBD1-Pad43_ +3.3V TRIGGER_0 Net-_LPC1343FBD1-Pad46_ Net-_LPC1343FBD1-Pad47_ Net-_LPC1343FBD1-Pad48_ LPC1343FBD48
U2  Net-_R5-Pad2_ Net-_R6-Pad2_ GND Net-_R12-Pad2_ +5V MAX9012
U1  Net-_R3-Pad2_ Net-_R4-Pad2_ GND Net-_R11-Pad2_ +5V MAX9012
R11  +3.3V Net-_R11-Pad2_ 820
R13  TRIGGER_0 Net-_R11-Pad2_ 120
R12  +3.3V Net-_R12-Pad2_ 820
R14  TRIGGER_1 Net-_R12-Pad2_ 120
X1  Net-_LPC1343FBD1-Pad37_ Net-_LPC1343FBD1-Pad38_ Net-_LPC1343FBD1-Pad40_ Net-_LPC1343FBD1-Pad42_ Net-_LPC1343FBD1-Pad43_ Net-_LPC1343FBD1-Pad46_ Net-_LPC1343FBD1-Pad47_ Net-_LPC1343FBD1-Pad48_ PIN_OUT_1
X6  Net-_PCF2127AT1-Pad14_ Net-_PCF2127AT1-Pad15_ Net-_C13-Pad2_ PIN_OUT_6
X3  Net-_LPC1343FBD1-Pad25_ ? Net-_LPC1343FBD1-Pad26_ Net-_LPC1343FBD1-Pad27_ PWM_1 Net-_LPC1343FBD1-Pad31_ Net-_LPC1343FBD1-Pad32_ Net-_LPC1343FBD1-Pad34_ Net-_LPC1343FBD1-Pad35_ Net-_LPC1343FBD1-Pad36_ PIN_OUT_3
X2  Net-_LPC1343FBD1-Pad1_ Net-_LPC1343FBD1-Pad2_ Net-_LPC1343FBD1-Pad4_ PIN_OUT_2
X4  Net-_LPC1343FBD1-Pad6_ Net-_LPC1343FBD1-Pad7_ Net-_LPC1343FBD1-Pad9_ Net-_LPC1343FBD1-Pad10_ Net-_LPC1343FBD1-Pad12_ PIN_OUT_4
X5  PWM_0 PWM_0
D1  Net-_C7-Pad1_ +3.3V LED
C10  Net-_C10-Pad1_ GND 10u
R6  DIVIDER_1 Net-_R6-Pad2_ 4k7
R5  Net-_C2-Pad1_ Net-_R5-Pad2_ 4k7
R4  DIVIDER_0 Net-_R4-Pad2_ 4k7
R3  Net-_C1-Pad1_ Net-_R3-Pad2_ 4k7
U3  Net-_D5-Pad1_ GND Net-_D6-Pad1_ MJ4435-R

.end
